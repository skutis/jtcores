File: cores/mzone/sch/shram.kicad_sch (KiCad schematic)
At the start: 10 parts

Commit message: mzone core
Connections:
- net CLK1 renamed PXCK1
